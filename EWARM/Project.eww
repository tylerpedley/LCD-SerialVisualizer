<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM31F103 Live Debug LCD.ewp</path>
  </project>
  <batchBuild />
</workspace>
